# Keil uVision project Project_mau.uvprojx, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00001000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project_mau
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072,
  c include: ..\Libraries\CMSIS\Device\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\MDK;..\USER;..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\Libraries\Utilities\STM32F072B-Discovery
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Main
    ../USER/: main.c Delay.c uart.c ct_lib.c motor_lib.c sys_lib.c spi_lib.c adc_lib.c
  group Lib
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group FILE_H
    ../USER/: Delay.h uart.h ct_lib.h pin_define.h motor_lib.h sys_lib.h spi_lib.h adc_lib.h
  group Startup
    ../USER/: system_stm32f0xx.c stm32f0xx.h system_stm32f0xx.h startup_stm32f030.s
